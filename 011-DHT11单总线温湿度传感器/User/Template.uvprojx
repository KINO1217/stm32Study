# Keil uVision project Template.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\FWLIB\inc;..\Myapp\inc;..\System
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group CMSIS
    ../CORE/: core_cm3.c startup_stm32f10x_md.s stm32f10x.h system_stm32f10x.c stm32f10x_it.c stm32f10x_conf.h
  group FWLIB
    ../FWLIB/src/: stm32f10x_gpio.c stm32f10x_rcc.c misc.c
  group SYSTEM
    ../System/: delay.c sys.c
  group MYAPP
    ../Myapp/src/: dht11.c
  group USER
    ./: main.c
